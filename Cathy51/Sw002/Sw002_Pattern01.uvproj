# Keil uVision project Sw002_Pattern01.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Sw002_Pattern +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Sw002_Pattern01.c
