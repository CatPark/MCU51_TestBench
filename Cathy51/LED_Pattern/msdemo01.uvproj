# Keil uVision project msdemo01.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: msdemo01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led_pattern.c start51.c
  group Libray
    ./: lib_timing.c lib_io.c
