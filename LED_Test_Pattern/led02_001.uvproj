# Keil uVision project led02_001.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: C007 +hex
  c flags: Optimize=8 SizeSpeed=1
  group sources
    ./: led02_001_pattern.c led02_001_start51.c
  group libray
    ./: led02_001_timing.c led02_001_io.c
