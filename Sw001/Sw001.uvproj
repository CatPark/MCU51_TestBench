# Keil uVision project Sw001.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C53RC STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3BFF) CLOCK(45000000) MODP2
  output: Sw002 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Sw002.c
